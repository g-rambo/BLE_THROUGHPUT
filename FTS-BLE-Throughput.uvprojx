# Keil uVision project FTS-BLE-Throughput.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.13.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FTS-BLE-Throughput
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c
  group nRF_Segger_RTT
    ./: RTT_Syscalls_KEIL.c SEGGER_RTT.c
  group nRF_SoftDevice
    ./: softdevice_handler.c
software components: CMSIS:CORE 5.0.1, Device:Startup 8.13.0, Device:StartupConfig 8.13.0
